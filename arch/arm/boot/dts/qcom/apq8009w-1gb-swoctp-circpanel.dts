/*
 * Copyright (c) 2016  The Linux Foundation. All rights reserved.
 *
 * This program is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License version 2 and
 * only version 2 as published by the Free Software Foundation.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 */

/dts-v1/;

#include "apq8009w-swoctp.dtsi"

/ {
	model = "Qualcomm Technologies, Inc. APQ8009W-PM8916 \
						1GB SWOC CIRC PANEL MTP";
	compatible = "qcom,apq8009-mtp", "qcom,apq8009", "qcom,mtp";
	qcom,msm-id = <265 0>,
		      <301 0>;
	qcom,board-id= <8 0xc>; /* SWOC P4 1GB with Circular display */
};

&soc {
	i2c@78b9000 { /* BLSP1 QUP5 */
		it7260@46 {
			reg = <0x46>;
			ite,panel-coords = <0 0 400 400>;
			ite,display-coords = <0 0 400 400>;
			ite,fw-name = "it7262_fw_050F0302.bin";
			ite,cfg-name = "it7262_cfg_6602780D.bin";
		};
	};
};
